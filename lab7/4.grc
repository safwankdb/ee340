<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_points</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fll_ntaps</value></param>
<param><key>value</key><value>55</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_bw</value></param>
<param><key>value</key><value>2*pi/100 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>1056</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_taps</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0,excess_bw, ntaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1600000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>slider1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>55000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100000</value></param>
<param><key>min</key><value>-100000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timing_bw</value></param>
<param><key>value</key><value>2*pi/100 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts,nfilts,1.0,excess_bw,ntaps)</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate/50</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>digital</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>0.0001</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>10</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>freq_bw</value></param>
<param><key>order</key><value>const_points</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>w</key><value>freq_bw</value></param>
<param><key>filter_size</key><value>fll_ntaps</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>16</value></param>
<param><key>loop_bw</key><value>timing_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>filt</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>pi</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>850e6-55000</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
