<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_1</value></param>
<param><key>value</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_2</value></param>
<param><key>value</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_3</value></param>
<param><key>value</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_4</value></param>
<param><key>value</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_5</value></param>
<param><key>value</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>var_1/100</value></param>
<param><key>high_cutoff_freq</key><value>500</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>var_2/100</value></param>
<param><key>high_cutoff_freq</key><value>3000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>500</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_3</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>var_3/100</value></param>
<param><key>high_cutoff_freq</key><value>6000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_3_0</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>var_4/100</value></param>
<param><key>high_cutoff_freq</key><value>9000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>6000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_3_1</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>gain</key><value>var_5/100</value></param>
<param><key>high_cutoff_freq</key><value>15000</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>9000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>5</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/safwankdb/Desktop/ee340_lab/lab1/Bach.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_3_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_3_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>band_pass_filter_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>band_pass_filter_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>band_pass_filter_0_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
